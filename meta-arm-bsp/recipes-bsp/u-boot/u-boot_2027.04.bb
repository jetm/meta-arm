require recipes-bsp/u-boot/u-boot-common.inc
require recipes-bsp/u-boot/u-boot.inc

SRCREV = "3f772959501c99fbe5aa0b22a36efe3478d1ae1c"
PV="2027.04"
